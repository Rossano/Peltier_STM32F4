# Keil uVision project application.uvproj, settings and files
target STM32F429I_DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I_DISCO
  c flags: Optim=1 wLevel=2
  c define: ST STM32F429xx USE_STM32F429I_DISCO USE_STDPERIPH_DRIVER HSE_VALUE=8000000 USE_BPP=24 USE_OS_SYSTICK
  c include: ..\TouchGFX\gui\include;..\TouchGFX\target\include;..\TouchGFX\platform\os;..\TouchGFX\generated\fonts\include;..\TouchGFX\generated\images\include;..\TouchGFX\generated\texts\include;..\TouchGFX\generated\gui_generated\include;../../middlewares/st/touchgfx/touchgfx/framework/include;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F429I-Discovery;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32f4xx\Include;..\TouchGFX\target;..\Core\Inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F429I_DISCO
    ../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery_ts.c stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c
  group Example/User
    ../Core/Src/: stm32f4xx_it.c main.cpp stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_hcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hash.c stm32f4xx_hal_adc.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dac.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_hash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_irda.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sai_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/mainscreen_screen/: mainscreenpresenter.cpp mainscreenview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/settingscreen_screen/: settingscreenpresenter.cpp settingscreenview.cpp
    ../touchgfx/gui/src/splashscreen_screen/: splashscreenpresenter.cpp splashscreenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp font_times_20_4bpp.cpp font_verdana_10_4bpp.cpp font_verdana_20_4bpp.cpp font_verdana_40_4bpp.cpp fontgetters.cpp kerning_times_20_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_times_20_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../touchgfx/generated/images/src/: arrow_dx.cpp arrow_sx.cpp bitmapdatabase.cpp black_background.cpp icon_auto.cpp icon_manual.cpp start.cpp stop.cpp
    ../touchgfx/generated/images/src/__designer/: blue_progressindicators_bg_medium_circle_indicator_bg_line_full.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/mainscreen_screen/: mainscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/settingscreen_screen/: settingscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/splashscreen_screen/: splashscreenviewbase.cpp
  group os
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group TouchGFX/Lib
    ../../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group TouchGFX/Target
    ../TouchGFX/target/: OSWrappers.cpp BoardConfiguration.cpp CortexMMCUInstrumentation.cpp GPIO.cpp ResistiveTouchController.cpp STM32F4DMA.cpp STM32F4HAL.cpp
